COMPATIBLE_MACHINE = "(tegra|intel-corei7-64)"