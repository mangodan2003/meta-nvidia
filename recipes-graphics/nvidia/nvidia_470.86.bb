include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

SRC_URI[md5sum] = "6620e8c931b5e33c5860793e5242edcf"
SRC_URI[sha256sum] = "4fb7a039dbd210648c785030e81844350b1b69e8d56c8da6953b050958673c4f"
